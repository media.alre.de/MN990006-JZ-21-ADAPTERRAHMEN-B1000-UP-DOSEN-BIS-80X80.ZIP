Properties of the parts of a building model (IFC4)

# File
Description: Adapterrahmen für Geräte der Serie Berlin 1000, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MN990006, Adapterrahmen für Geräte der Serie Berlin 1000
In: Raum
Description: Adapterrahmen zur Aufnahme von Geräten der Serie Berlin 1000 auf UP-Dosen bis 80 x 80 mm.; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MN990006; ModelLabel: JZ-21; GlobalTradeItemNumber: 4050528074386; ProductURL: https://alre.de/produkt_MN990006
Pset_Specification - NominalLength: 0.0883 m; NominalWidth: 0.088 m; NominalDepth: 0.0028 m; NetWeight: 0.02
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 88; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MN990006.pdf
